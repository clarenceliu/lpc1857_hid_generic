# Keil uVision project freertos_tcpecho.uvproj, settings and files
target iflash_keil_mcb_1857 (ARM-ADS)
  device: LPC1857 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x1A000000-0x1A07FFFF) IROM2(0x1B000000-0x1B07FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: freertos_tcpecho
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x1A000000)
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M3
  c include: ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx\config_18xx;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx\keil_mcb_1857;..\..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\..\..\software\lwip\contrib\apps\tcpecho;..\..\..\..\..\..\software\lwip\lwip\src\include\ipv4;..\..\..\..\..\..\software\lwip\lwip\src\include;..\..\..\..\..\..\software\lwip\lpclwip;..\..\..\..\examples\lwip\freertos_tcpecho\configs;..\..\..\..\..\..\software\freertos\freertos\Source\portable\RVDS\ARM_CM3;..\..\..\..\..\..\software\freertos\freertos\Source\include
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group src
    ../../../../startup_code/: sysinit.c
    ../../../../examples/lwip/startup_code/: keil_startup_lpc18xx43xx.s
    ../../../../../../software/lwip/contrib/apps/tcpecho/: tcpecho.c
    ../../../../examples/lwip/freertos_tcpecho/: freertos_tcpecho.c readme.txt
  group lwip
    ../../../../../../software/lwip/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../../../software/lwip/lwip/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../../../../../software/lwip/lwip/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../../../../../software/lwip/lwip/src/netif/: etharp.c ethernetif.c
    ../../../../../../software/lwip/lpclwip/arch/: lpc_debug.c lpc18xx_43xx_emac.c sys_arch_freertos.c
  group freertos
    ../../../../../../software/freertos/freertoslpc/: FreeRTOSCommonHooks.c
    ../../../../../../software/freertos/freertos/Source/: list.c queue.c tasks.c
    ../../../../../../software/freertos/freertos/Source/portable/MemMang/: heap_3.c
    ../../../../../../software/freertos/freertos/Source/portable/RVDS/ARM_CM3/: port.c
    ../../../../examples/lwip/freertos_tcpecho/: readme.txt
  group lib
    ../../../../../../software/lpc_core/lpc_board/boards_18xx/keil_mcb_1857/keil_output/core_m3/: lib_lpc_board_keil_mcb_1857.lib
    ../../../../../../software/lpc_core/lpc_chip/chip_18xx_43xx/keil_output/core_m3/: lib_lpc_chip_18xx.lib
