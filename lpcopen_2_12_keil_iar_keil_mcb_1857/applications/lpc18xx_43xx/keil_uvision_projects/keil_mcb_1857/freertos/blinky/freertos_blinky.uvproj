# Keil uVision project freertos_blinky.uvproj, settings and files
target iflash_keil_mcb_1857 (ARM-ADS)
  device: LPC1857 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x1A000000-0x1A07FFFF) IROM2(0x1B000000-0x1B07FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: freertos_blinky
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x1A000000)
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M3
  c include: ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx\config_18xx;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx\keil_mcb_1857;..\..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\..\..\software\freertos\freertos\Source\include;..\..\..\..\..\..\software\freertos\freertos\Source\portable\RVDS\ARM_CM3;..\..\..\..\examples\freertos\freertos_blinky
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group src
    ../../../../startup_code/: sysinit.c
    ../../../../examples/freertos/freertos_blinky/: freertos_blinky.c readme.txt
    ../../../../examples/freertos/startup_code/: keil_freertos_startup_lpc18xx43xx.s
  group lib
    ../../../../../../software/lpc_core/lpc_board/boards_18xx/keil_mcb_1857/keil_output/core_m3/: lib_lpc_board_keil_mcb_1857.lib
    ../../../../../../software/lpc_core/lpc_chip/chip_18xx_43xx/keil_output/core_m3/: lib_lpc_chip_18xx.lib
    ../../../../examples/freertos/freertos_blinky/: readme.txt
  group freertos
    ../../../../../../software/freertos/freertos/Source/: list.c queue.c tasks.c
    ../../../../../../software/freertos/freertos/Source/portable/MemMang/: heap_3.c
    ../../../../../../software/freertos/freertos/Source/portable/RVDS/ARM_CM3/: port.c
    ../../../../../../software/freertos/freertoslpc/: FreeRTOSCommonHooks.c
