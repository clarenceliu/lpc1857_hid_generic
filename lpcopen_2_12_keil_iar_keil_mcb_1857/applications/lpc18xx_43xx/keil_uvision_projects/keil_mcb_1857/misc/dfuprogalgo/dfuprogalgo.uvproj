# Keil uVision project dfuprogalgo.uvproj, settings and files
target iflash_keil_mcb_1857 (ARM-ADS)
  device: LPC1857 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x1A000000-0x1A07FFFF) IROM2(0x1B000000-0x1B07FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: dfuprogalgo
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output dfuprogalgo.bin !L
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M3
  c include: ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx\config_18xx;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\..\software\lpc_core\lpc_board\boards_18xx\keil_mcb_1857;..\..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\..\..\software\lpc_core\lpc_chip\usbd_rom;..\..\..\..\examples\dfuutil\dfuutil_common;..\..\..\..\examples\dfuutil\dfuutil_programming_any;..\..\..\..\..\..\software\lpcspifilib\inc
  memory RVCT4: ROM 0x10000000 size 0x8000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10080000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group src
    ../../../../startup_code/: keil_startup_lpc18xx43xx.s
    ../../../../examples/dfuutil/dfuutil_programming_any/: dfuutil_programming_spiflash_algorithm.c dfuutil_programming_root_algorithm .c dfuutil_programming_iflash_algorithm.c dfuutil_programming_eeprom_algorithm.c dfuutil_programming_any_systeminit.c dfuutil_programming_any_algorithm.c readme.txt
    ../../../../examples/dfuutil/dfuutil_common/: dfuutil_programming_dfu_usbdesc.c dfuutil_programming_dfu_ops.c
  group lib
    ../../../../../../software/lpc_core/lpc_board/boards_18xx/keil_mcb_1857/keil_output/core_m3/: lib_lpc_board_keil_mcb_1857.lib
    ../../../../../../software/lpc_core/lpc_chip/chip_18xx_43xx/keil_output/core_m3/: lib_lpc_chip_18xx.lib
    ../../../../../../software/lpcspifilib/lib/keil/: lib_lpcspifi_M3.lib
