# Keil uVision project lib_lpc_board_keil_mcb_1857.uvproj, settings and files
target keil_mcb_1857 (ARM-ADS)
  device: LPC1857 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x1A000000-0x1A07FFFF) IROM2(0x1B000000-0x1B07FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: lib_lpc_board_keil_mcb_1857 (library)
  c flags: Optim=4 OneElfS=1
  c define: CORE_M3
  c include: ..\..\..\lpc_chip\chip_18xx_43xx;..\..\..\lpc_chip\chip_18xx_43xx\config_18xx;..\..\..\lpc_chip\chip_common;..\..\board_common;.\
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group src
    ./: board.c board_sysinit.c
    ../../board_common/: mem_tests.c uda1380.c lpc_phy_dp83848.c
